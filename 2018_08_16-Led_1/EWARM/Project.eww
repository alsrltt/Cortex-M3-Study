<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\2018_08_16-Led_1.ewp</path>
  </project>
  <batchBuild />
</workspace>
